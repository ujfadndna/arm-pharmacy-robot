# Keil uVision project FSP_Project.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: FSP_Project +hex
  c flags: v6Lang=3 v6LangP=6
  c misc: @via/rasc_armclang.via
  c include: .\ra\arm\CMSIS_6\CMSIS\DSP\Include
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group src
    ./src/: cabinet_state.c motor_ctrl_step.c degradation.c rtmon.c taskmon.c medicine_db.c log.c motor_can_dummy.c motion_controller.c motor_test.c usb_host_cdc.c dummy_arm_cmd.c drv_iic0.c wm8960.c drv_ssi0.c audio.c flash_storage.c vacuum_pump.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c new_thread0_entry.c freertos_hooks.c app_common.c cabinet_config.c kinematics.c motor_can_dummy.c trajectory.c vision_wifi.c w800_driver.c w800_cmd_handler.c app_common.h cabinet_config.h kinematics.h motor_can.h trajectory.h vision_protocol.h vision_wifi.h w800_driver.h w800_cmd_handler.h debug_uart.c debug_uart.h llm_action.c llm_action.h motion_controller.c motion_controller.h arm_mat_init_f32.c arm_mat_mult_f32.c canfd_afl.c fast_math.c fast_math.h gripper.c gripper.h kin_math.h watchdog.c watchdog.h llm_test.c llm_test.h zdt_test.c zdt_test.h motor_can.c cabinet_demo.c cabinet_demo.h cabinet_executor.c cabinet_executor.h cabinet_main.c cabinet_main.h cabinet_state.c cabinet_state.h degradation.c degradation.h log.c log.h medicine_db.c medicine_db.h motor_can_dummy.h motor_ctrl_step.c motor_ctrl_step.h motor_sca.c motor_sca.h motor_test.c motor_test.h pid_tuner.c pid_tuner.h rtmon.c rtmon.h taskmon.c taskmon.h visual_servo.c visual_servo.h dummy_arm_cmd.c dummy_arm_cmd.h usb_host_cdc.c usb_host_cdc.h usb_host_cdc_rasc_guide.h audio.c audio.h drv_iic0.c drv_iic0.h drv_ssi0.c drv_ssi0.h wm8960.c wm8960.h maixcam_uart.c maixcam_uart.h slot_teach.c slot_teach.h
software components: Flex Software:RA Configuration 1.0.0
